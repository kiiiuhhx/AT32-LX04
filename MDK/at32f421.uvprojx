# Keil uVision project at32f421.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: at32f421 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\CMSIS\inc;..\Lib\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../CMSIS/src/: at32f421_clock.c at32f421_int.c system_at32f421.c
  group Startup
    ../Startup/: startup_at32f421.s
  group Lib
    ../Lib/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group FreeRTOS_port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_src
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Base
    ../User/Base/src/: init.c main.c
  group Module_ADC
    ../User/ADC/inc/: adc_macros.h
    ../User/ADC/src/: adc_init.c adc_interface.c adc_task.c adc_user.c
  group Module_Beep
    ../User/Beep/inc/: beep_macros.h
    ../User/Beep/src/: beep_init.c beep_interface.c beep_task.c beep_user.c
  group Module_Key
    ../User/Key/inc/: key_macros.h
    ../User/Key/src/: key_init.c key_interface.c key_task.c key_user.c
  group Module_LCD
    ../User/LCD/inc/: lcd_macros.h
    ../User/LCD/src/: lcd_font.c lcd_init.c lcd_interface.c lcd_picture.c lcd_task.c lcd_user.c
  group Module_LED
    ../User/LED/inc/: led_macros.h
    ../User/LED/src/: led_init.c led_interface.c led_task.c led_user.c
  group Module_PWM
    ../User/PWM/inc/: pwm_macros.h
    ../User/PWM/src/: pwm_init.c pwm_interface.c pwm_task.c pwm_user.c
  group Module_RS485
    ../User/RS485/inc/: rs485_macros.h
    ../User/RS485/src/: rs485_init.c rs485_interface.c rs485_task.c rs485_user.c
  group Module_Servo
    ../User/Servo/inc/: servo_macros.h
    ../User/Servo/src/: servo_init.c servo_interface.c servo_task.c servo_user.c
  group Module_USART
    ../User/USART/inc/: usart_macros.h
    ../User/USART/src/: usart_init.c usart_interface.c usart_task.c usart_user.c
  group Module_WS2812
    ../User/WS2812/inc/: ws2812_macros.h
    ../User/WS2812/src/: ws2812_init.c ws2812_interface.c ws2812_task.c ws2812_user.c
